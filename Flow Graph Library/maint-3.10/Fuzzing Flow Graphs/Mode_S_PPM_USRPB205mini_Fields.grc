options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: Mode_S_PPM_USRPB205mini_Fields
    output_language: python
  states: {}

blocks:
- name: fuzzing_data
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: fuzzing_fields
  id: variable
  parameters:
    value: '"[''ICAO'']"'
  states: {}
- name: fuzzing_interval
  id: variable
  parameters:
    value: '"1"'
  states: {}
- name: fuzzing_max
  id: variable
  parameters:
    value: '"[''16777215'']"'
  states: {}
- name: fuzzing_min
  id: variable
  parameters:
    value: '"[''0'']"'
  states: {}
- name: fuzzing_packet_type
  id: variable
  parameters:
    value: '"ADS-B Airborne Position - Odd"'
  states: {}
- name: fuzzing_protocol
  id: variable
  parameters:
    value: '"Mode S"'
  states: {}
- name: fuzzing_seed
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: fuzzing_type
  id: variable
  parameters:
    value: '"[''Random'']"'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '70'
  states: {}
- name: packet_types_fields
  id: variable
  parameters:
    value: '"{}"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: serial
  id: variable
  parameters:
    value: '"False"'
  states: {}
- name: transmit_interval
  id: variable
  parameters:
    value: '.1'
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: tx_usrp_channel
  id: variable
  parameters:
    value: '"A:A"'
  states: {}
- name: adsb_decoder_0
  id: adsb_decoder
  parameters:
    error_corr: '"None"'
    msg_filter: '"Extended Squitter Only"'
    print_level: '"Brief"'
  states: {}
- name: adsb_framer_0
  id: adsb_framer
  parameters:
    fs: 2e6
    threshold: '0.01'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /dev/stdout
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/user/Desktop/Fuzzed/data.bin
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_source_0
  id: blocks_message_source
  parameters:
    type: byte
    vlen: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '.3'
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_correlate_access_code_tag_bb_0
  id: digital_correlate_access_code_tag_bb
  parameters:
    access_code: '1010000101000000'
    tagname: adsb_preamble
    threshold: '0'
  states: {}
- name: fuzzer_fuzzer_0_0
  id: fuzzer_fuzzer
  parameters:
    fuzzing_data: fuzzing_data
    fuzzing_fields: fuzzing_fields
    fuzzing_interval: fuzzing_interval
    fuzzing_max: fuzzing_max
    fuzzing_min: fuzzing_min
    fuzzing_packet_type: fuzzing_packet_type
    fuzzing_protocol: fuzzing_protocol
    fuzzing_seed: fuzzing_seed
    fuzzing_type: fuzzing_type
    packet_types_fields: packet_types_fields
  states: {}
- name: fuzzer_packet_insert_0
  id: fuzzer_packet_insert
  parameters:
    offset: '0'
    period: int(samp_rate*transmit_interval/8)
    vector: '0'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: tx_freq
    clock_rate: '0.0'
    dev_addr: serial
    dev_args: '""'
    gain0: gain
    len_tag_name: ''
    samp_rate: samp_rate
    sd_spec0: tx_usrp_channel
    sync: sync
    type: fc32
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: '"tcp://127.0.0.1:" + str(4444)'
    timeout: '100'
    type: byte
  states: {state: disabled}

connections:
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']
- [blocks_message_source_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_null_source_0, '0', fuzzer_packet_insert_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_tag_bb_0, '0']
- [digital_correlate_access_code_tag_bb_0, '0', adsb_framer_0, '0']
- [fuzzer_fuzzer_0_0, packet_out, blocks_message_debug_0, print]
- [fuzzer_fuzzer_0_0, packet_out, fuzzer_packet_insert_0, packet_in]
- [fuzzer_packet_insert_0, '0', blocks_unpack_k_bits_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
