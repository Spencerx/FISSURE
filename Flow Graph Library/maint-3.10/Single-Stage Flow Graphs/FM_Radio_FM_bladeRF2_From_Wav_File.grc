options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: FM_Radio_FM_bladeRF2_From_Wav_File
    output_language: python
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: filepath
  id: variable
  parameters:
    value: '"/home/user/FISSURE/Flow Graph Library/Single-Stage Flow Graphs/Attack Files/tone.wav"'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Converts a .wav file to an FM signal."'
  states: {}
- name: repeat
  id: variable
  parameters:
    value: '"Yes"'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: serial
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: tx_frequency
  id: variable
  parameters:
    value: 96.9e6
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '480000'
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: filepath
    repeat: 'True'
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: audio_rate/sample_rate
    type: float
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"bladerf=" + str(serial)'
    bb_gain0: '20'
    freq0: tx_frequency
    gain0: tx_gain
    if_gain0: '20'
    sample_rate: sample_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    center_freq: float(tx_frequency)
    dev_args: '"bladerf=" + str(serial)'
    gain: float(tx_gain)
    samp_rate: sample_rate
    type: fc32
  states: {}

connections:
- [analog_wfm_tx_0, '0', osmosdr_sink_0, '0']
- [analog_wfm_tx_0, '0', soapy_bladerf_sink_0, '0']
- [blocks_wavfile_source_0, '0', mmse_resampler_xx_0, '0']
- [mmse_resampler_xx_0, '0', analog_wfm_tx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
