options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: time_sink_1_10_100_bladerf2
    output_language: python
  states: {}

blocks:
- name: rx_frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,4
    label: ' Freq. (MHz):'
    start: '50'
    step: '.1'
    stop: '3800'
    value: '2412'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,4
    label: '              Gain:'
    start: '-1'
    step: '1'
    stop: '60'
    value: '50'
  states: {}
- name: sample_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Sample Rate
    labels: '["1 MS/s", "5 MS/s", "10 MS/s", "20 MS/s"]'
    num_opts: '0'
    options: '[1e6, 5e6, 10e6, 20e6]'
    type: real
    value: 1e6
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '10'
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '100'
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"bladerf=" + str(serial)'
    bb_gain0: '20'
    freq0: rx_frequency*1e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: rx_gain
    sample_rate: sample_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 3,0,10,4
    label1: ''
    label2: ''
    name: '"1 in 1"'
    size: '100000'
    srate: sample_rate
    tr_level: '0.005'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 15,0,10,4
    label1: ''
    label2: ''
    name: '"1 in 10"'
    size: '100000'
    srate: sample_rate
    tr_level: '0.005'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 26,0,10,4
    label1: ''
    label2: ''
    name: '"1 in 100"'
    size: '100000'
    srate: sample_rate
    tr_level: '0.005'
    type: complex
    update_time: '0.1'
  states: {}
- name: serial
  id: parameter
  parameters:
    label: serial
    type: str
    value: '"0"'
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: float(rx_frequency)*1e6
    dev_args: '"bladerf=" + str(serial)'
    gain: float(rx_gain)
    samp_rate: float(sample_rate)
    type: fc32
  states: {}

connections:
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_keep_one_in_n_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [osmosdr_source_0, '0', blocks_keep_one_in_n_0, '0']
- [osmosdr_source_0, '0', blocks_keep_one_in_n_0_0, '0']
- [osmosdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [soapy_bladerf_source_0, '0', blocks_keep_one_in_n_0, '0']
- [soapy_bladerf_source_0, '0', blocks_keep_one_in_n_0_0, '0']
- [soapy_bladerf_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
