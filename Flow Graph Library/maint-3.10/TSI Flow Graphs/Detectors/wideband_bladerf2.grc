options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: wideband_bladerf2
    output_language: python
  states: {}

blocks:
- name: antenna
  id: variable
  parameters:
    value: '"N/A"'
  states: {}
- name: channel
  id: variable
  parameters:
    value: '"N/A"'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: 512*1
  states: {}
- name: gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: ip_address
  id: variable
  parameters:
    value: '"N/A"'
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: 1200e6
  states: {}
- name: rx_freq_0
  id: variable_qtgui_range
  parameters:
    label: rx_freq
    start: 2400e6
    step: 1e6
    stop: 2500e6
    value: 2425.e6
  states: {state: disabled}
- name: sample_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: sensor_node_ip_address
  id: variable
  parameters:
    value: '"127.0.0.1"'
  states: {state: disabled}
- name: serial
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '-70'
  states: {}
- name: threshold_0
  id: variable_qtgui_range
  parameters:
    label: Threshold
    start: '-120'
    step: '1'
    stop: '50'
    value: '-50'
  states: {state: disabled}
- name: ainfosec_wideband_detector1_0
  id: ainfosec_wideband_detector1
  parameters:
    address: '"tcp://127.0.0.1:5060"'
    fft_size: fft_size
    rx_freq: rx_freq
    sample_rate: sample_rate
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-70'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '10'
    max_iter: '4000'
    scale: '10'
    type: float
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'False'
    type: cc
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"bladerf=" + str(serial)'
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: rx_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: gain
    iq_balance_mode0: '1'
    sample_rate: sample_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: fft_size
    srate: '1'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: fft_size*1000
    srate: '1'
    type: complex
  states: {state: disabled}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: float(rx_freq)
    dev_args: '"bladerf=" + str(serial)'
    gain: float(gain)
    samp_rate: float(sample_rate)
    type: fc32
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', blocks_stream_to_vector_1, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', ainfosec_wideband_detector1_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_stream_to_vector_1, '0', fft_vxx_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_squared_0, '0']
- [dc_blocker_xx_0, '0', analog_pwr_squelch_xx_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [osmosdr_source_0, '0', dc_blocker_xx_0, '0']
- [soapy_bladerf_source_0, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
