options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: X10_OOK_USRPX310_Fields
    output_language: python
  states: {}

blocks:
- name: address_code
  id: variable
  parameters:
    value: '"0x60"'
  states: {}
- name: data_code
  id: variable
  parameters:
    value: '"0x00"'
  states: {}
- name: fuzzing_data
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: fuzzing_fields
  id: variable
  parameters:
    value: '"[''Address Code'']"'
  states: {}
- name: fuzzing_interval
  id: variable
  parameters:
    value: '"5"'
  states: {}
- name: fuzzing_max
  id: variable
  parameters:
    value: '"[''65535'']"'
  states: {}
- name: fuzzing_min
  id: variable
  parameters:
    value: '"[''0'']"'
  states: {}
- name: fuzzing_packet_type
  id: variable
  parameters:
    value: '"Default"'
  states: {}
- name: fuzzing_protocol
  id: variable
  parameters:
    value: '"X10"'
  states: {}
- name: fuzzing_seed
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: fuzzing_type
  id: variable
  parameters:
    value: '"[''Random'']"'
  states: {}
- name: ip_address
  id: variable
  parameters:
    value: '"192.168.40.1"'
  states: {}
- name: packet_types_fields
  id: variable
  parameters:
    value: '"{}"'
  states: {}
- name: press_duration
  id: variable
  parameters:
    value: transmit_interval/2
  states: {state: disabled}
- name: press_repetition_interval
  id: variable
  parameters:
    value: transmit_interval
  states: {state: disabled}
- name: rx_usrp_frequency
  id: variable
  parameters:
    value: 310.8e6
  states: {state: disabled}
- name: rx_usrp_gain
  id: variable
  parameters:
    value: '60'
  states: {state: disabled}
- name: sample_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: string_variables
  id: variable
  parameters:
    value: '["address_code","data_code"]'
  states: {}
- name: transmit_interval
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_usrp_antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: tx_usrp_channel
  id: variable
  parameters:
    value: '"A:0"'
  states: {}
- name: tx_usrp_gain
  id: variable
  parameters:
    value: '33'
  states: {}
- name: X10_msg_gen_fuzzer_0
  id: X10_msg_gen_fuzzer
  parameters:
    address_code: address_code
    data_code: data_code
    press_duration: transmit_interval/2
    press_repetition_interval: transmit_interval
    sample_rate: sample_rate
  states: {}
- name: X10_x10_decoder_0
  id: X10_x10_decoder
  parameters: {}
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {state: disabled}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '125'
    type: float
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.9'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1000'
    type: float
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '.02'
    init: '0'
    low: '.02'
  states: {state: disabled}
- name: digital_correlate_access_code_tag_bb_0
  id: digital_correlate_access_code_tag_bb
  parameters:
    access_code: '111111111111111111111111111111111111111100000000000000000000'
    tagname: Start
    threshold: '0'
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[0.125]*8'
    type: fff
  states: {state: disabled}
- name: fuzzer_fuzzer_0_0
  id: fuzzer_fuzzer
  parameters:
    fuzzing_data: fuzzing_data
    fuzzing_fields: fuzzing_fields
    fuzzing_interval: fuzzing_interval
    fuzzing_max: fuzzing_max
    fuzzing_min: fuzzing_min
    fuzzing_packet_type: fuzzing_packet_type
    fuzzing_protocol: fuzzing_protocol
    fuzzing_seed: fuzzing_seed
    fuzzing_type: fuzzing_type
    packet_types_fields: packet_types_fields
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '10000'
    srate: '1'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '10000'
    srate: '1'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '100000'
    srate: '1'
    type: float
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: tx_usrp_antenna
    center_freq0: 310.7e6
    clock_rate: '0.0'
    dev_addr: '"ip_addr=" + ip_address'
    dev_args: '""'
    gain0: tx_usrp_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: sample_rate
    sd_spec0: tx_usrp_channel
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: rx_usrp_frequency
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '50'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: sample_rate
    sd_spec0: tx_usrp_channel
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: rx_usrp_frequency
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: '"ip_addr=192.168.40.1"'
    dev_args: '""'
    gain0: '33'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: sample_rate
    sd_spec0: '"A:0"'
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [X10_msg_gen_fuzzer_0, '0', blocks_multiply_const_vxx_0, '0']
- [X10_x10_decoder_0, out, blocks_message_debug_0, print]
- [blocks_char_to_float_0, '0', X10_x10_decoder_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', fir_filter_xxx_0, '0']
- [blocks_float_to_uchar_0, '0', digital_correlate_access_code_tag_bb_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_threshold_ff_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_null_source_0, '0', X10_msg_gen_fuzzer_0, '0']
- [blocks_threshold_ff_0, '0', blocks_keep_one_in_n_0, '0']
- [digital_correlate_access_code_tag_bb_0, '0', blocks_char_to_float_0, '0']
- [fir_filter_xxx_0, '0', blocks_multiply_const_vxx_1, '0']
- [fuzzer_fuzzer_0_0, packet_out, X10_msg_gen_fuzzer_0, fuzzer_in]
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
